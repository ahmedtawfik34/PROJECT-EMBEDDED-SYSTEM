# Keil uVision project projectss.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: projectss
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\cpp;.\docs;.\include;.\src;.\tests
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./src/: adc_temp.c alert.c app.c gpiof.c gptm_timers.c interrupt_handlers.c main.c systick_timer.c uart0.c
    ./include/: adc_temp.h alert.h app.h app_logic.h app_shared.h common_macros.h gpiof.h gptm_timers.h platform.h Std_Types.h systick_timer.h tm4c123gh6pm_.h uart0.h
    ./docs/: board_test_plan.md command_reference.md demo_video_script_5min.md run_project_step_by_step.md
    ./cpp/: app_logic.cpp
software components: CMSIS:CORE 6.2.0, Device:Startup 1.0.1
